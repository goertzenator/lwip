<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ea1788_httpraw_sa.ewp</path>
  </project>
  <batchBuild/>
</workspace>


