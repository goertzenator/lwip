# Keil uVision project ea1788_tcpecho_sa.uvproj, settings and files
target DRAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: example +hex
  c flags: Optim=4 wLevel=1
  c include: ..\source;..\..\..\..\..\arch;..\..\..\..\..\..\..\LPC177X_8X\Drivers\include;..\..\..\..\..\..\..\LPC177X_8X\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\LPC177X_8X\BoardSupport;..\..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\dram;..\..\..\..\..\arch\lpc177x_8x
  asm define: USE_SDRAM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\ea1788_common\keil\configs\DRAM.sct
  group Startup
    ../../../../../../../LPC177X_8X/BoardSupport/: sdram_is42s32800d.c
    ../../ea1788_common/keil/: startup_ea1788.s
  group CMSIS-CM3
    ../../../../../../../LPC177X_8X/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../../../../LPC177X_8X/drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_timer.c
    ../../../../../../../LPC177X_8X/Drivers/source/: debug_frmwrk.c lpc177x_8x_uart.c
  group Application
    ../../../../../../../lwip_lpc/nxpcommon/arch/: lpc_debug.c sys_arch.c Retarget.c
    ../../../../../../../lwip_lpc/nxpcommon/arch/lpc177x_8x/: lpc17_emac.c lpc177x_8x_systick_arch.c
    ../../ea1788_common/: ea1788_board.c
    ../../../../../../contrib-1.4.0/apps/tcpecho_raw/: echo.c
    ../../../../../: lpc_phy_lan8720.c
    ../source/: ea1788_tcpecho_sa.c
  group lwip
    ../../../../../../../lwip_lpc/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../../lwip_lpc/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../../lwip_lpc/lwip-1.4.0/src/netif/: etharp.c
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  c flags: Optim=4 wLevel=1
  c include: ..\source;..\..\..\..\..\arch;..\..\..\..\..\..\..\LPC177X_8X\Drivers\include;..\..\..\..\..\..\..\LPC177X_8X\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\LPC177X_8X\BoardSupport;..\..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\flash;..\..\..\..\..\arch\lpc177x_8x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\ea1788_common\keil\configs\FLASH.sct
target IRAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: __RAM_MODE__
  c include: ..\source;..\..\..\..\..\arch;..\..\..\..\..\..\..\LPC177X_8X\Drivers\include;..\..\..\..\..\..\..\LPC177X_8X\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\LPC177X_8X\BoardSupport;..\..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\iram;..\..\..\..\..\arch\lpc177x_8x
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\ea1788_common\keil\configs\IRAM.sct
