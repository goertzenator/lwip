# Keil uVision project hitex4350_http_sa.uvproj, settings and files
target IRAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M4 LPC43XX
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\LPC43XX\Drivers\include;..\..\..\..\..\..\..\..\LPC43XX\Core\Device\NXP\LPC43xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\LPC43XX\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw;..\source\configs\iram;..\..\..\..\..\..\arch\lpc18xx_43xx
  library: MicroLIB
  scatter file: ..\..\hitex4350_common\keil\configs\IRAM.sct
  group Startup
    ../../../../../../../../LPC43XX/Core/Device/NXP/LPC43xx/Source/: fpu_init.c fpu_enable.c
    ../../../../../../../../LPC43XX/Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../../hitex4350_common/keil/: startup_hitex4350_M4.s
  group Drivers
    ../../../../../../../../LPC43XX/Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_uart.c
  group Application
    ../../../../../../../../lwip_lpc/nxpcommon/arch/: lpc_debug.c sys_arch.c Retarget.c
    ../../../../../../arch/lpc18xx_43xx/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c
    ../../hitex4350_common/: hitex4350_board.c
    ../../../../../../: lpc_phy_dp83848.c
    ../../../../../../../contrib-1.4.0/apps/httpserver_raw/: httpd.c fs.c
    ../source/: hitex1850_http_sa.c
  group lwip
    ../../../../../../../../lwip_lpc/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../../../lwip_lpc/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../../../lwip_lpc/lwip-1.4.0/src/netif/: etharp.c
target SPIFI64 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M4 LPC43XX
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\LPC43XX\Drivers\include;..\..\..\..\..\..\..\..\LPC43XX\Core\Device\NXP\LPC43xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\LPC43XX\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw;..\source\configs\spifi64;..\..\..\..\..\..\arch\lpc18xx_43xx
  library: MicroLIB
  scatter file: ..\..\hitex4350_common\keil\configs\spifi64.sct
target flash (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M4 LPC43XX
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\LPC43XX\Drivers\include;..\..\..\..\..\..\..\..\LPC43XX\Core\Device\NXP\LPC43xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\LPC43XX\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw;..\source\configs\flash;..\..\..\..\..\..\arch\lpc18xx_43xx
  library: MicroLIB
  scatter file: ..\..\hitex4350_common\keil\configs\flash.sct
